# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\;..\..\..\..\Library\Device\Nuvoton\NUC990\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC990
  asm include: ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC990
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\nuc990.sct
  link misc: --entry 0x8000
  group User
    ../: main.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM9_NUC990/: port.c portASM.s
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../ThirdParty/FreeRTOS/Source/: queue.c tasks.c timers.c list.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: PollQ.c
  group lib
    ../../../../Library/StdDriver/src/: sys.c cache.c uart.c retarget.c clk.c
    ../../../../Library/Device/Nuvoton/NUC990/Source/Keil/: startup.s vector.s
