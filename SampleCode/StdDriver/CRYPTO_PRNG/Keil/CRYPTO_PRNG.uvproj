# Keil uVision project CRYPTO_PRNG.uvproj, settings and files
target CRYPTO_PRNG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: CRYPTO_PRNG
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC990\Include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\nuc990.sct
  link misc: --entry 0x8000
  group Device
    ../../../../Library/Device/Nuvoton/NUC990/Source/Keil/: startup.s vector.s
  group Library
    ../../../../Library/StdDriver/src/: cache.c clk.c crypto.c retarget.c sys.c uart.c
  group User
    ../: main.c
