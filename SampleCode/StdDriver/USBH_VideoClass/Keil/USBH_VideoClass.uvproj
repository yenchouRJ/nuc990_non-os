# Keil uVision project USBH_VideoClass.uvproj, settings and files
target USBH_VideoClass (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: USBH_VideoClass
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC990\Include;..\..\..\..\Library\UsbHostLib\inc;..\..\..\..\ThirdParty\FatFs\source
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\nuc990.sct
  link misc: --entry 0x8000
  group Device
    ../../../../Library/Device/Nuvoton/NUC990/Source/Keil/: startup.s vector.s
  group Library
    ../../../../Library/StdDriver/src/: cache.c clk.c crypto.c retarget.c sys.c uart.c timer.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c hub.c mem_alloc.c ohci.c support.c usb_core.c ehci_iso.c
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
    ../../../../Library/UsbHostLib/src_msc/: msc_xfer.c msc_driver.c
    ../../../../Library/UsbHostLib/src_uvc/: uvc_core.c uvc_driver.c uvc_parser.c
  group User
    ../: main.c diskio.c
  group FatFS
    ../../../../ThirdParty/FatFs/source/: ff.c ffunicode.c
