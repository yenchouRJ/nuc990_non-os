# Keil uVision project LwIP_MQTT.uvproj, settings and files
target LwIP_MQTT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: LwIP_MQTT +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: LWIP_ENABLE_CLIENT_CA=1 FREERTOS MBEDTLS_ALLOW_PRIVATE_ACCESS MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c misc: --diag_suppress=550,177,C4017,111,188,66
  c include: ..\;..\..\..\..\Library\Device\Nuvoton\NUC990\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC990;..\..\..\..\ThirdParty\lwIP\src\include;..\..\lwIPShare\include;..\..\..\..\ThirdParty\mbedtls-3.1.0\include;..\..\..\..\ThirdParty\mbedtls-3.1.0\library;..\..\..\..\ThirdParty\mbedtls-3.1.0\tests\include;..\src\mbedtls_app;..\src\mqtt_app;..\src\config;..\..\..\..\ThirdParty\paho.mqtt.embedded-c\MQTTPacket\src
  asm include: ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC990
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\nuc990.sct
  link misc: --entry 0x8000
  group User
    ../: main.c
    ../../lwIPShare/: sys_arch.c
    ../../lwIPShare/netif/: ethernetif.c eth.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM9_NUC990/: port.c portASM.s
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: BlockQ.c semtest.c PollQ.c GenQTest.c QueueSet.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group lib
    ../../../../Library/StdDriver/src/: sys.c cache.c uart.c retarget.c crypto.c clk.c
    ../../../../Library/Device/Nuvoton/NUC990/Source/Keil/: startup.s vector.s
  group LwIP
    ../../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip/src/netif/: ethernet.c
  group mbedtls
    ../../../../ThirdParty/mbedtls-3.1.0/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
  group MQTT_App
    ../src/app/: lan.c
    ../src/mbedtls_app/: lwip_tls.c platform_alt.c threading_alt.c
    ../src/mqtt_app/: mqtt-client.c mqtt-tcp.c
  group MQTT
    ../../../../ThirdParty/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
